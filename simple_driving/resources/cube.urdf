Commit message: Update cube.urdf

File: simple_driving/resources/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.75 0.75 0.75; visual box size=0.75 0.75 0.75
